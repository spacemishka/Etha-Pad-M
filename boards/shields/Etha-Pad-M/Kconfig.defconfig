## boards/shields/Etha-Pad-M/Kconfig.defconfig
```kconfig
if SHIELD_ETHAPADM

config ZMK_USB
	default n

config ZMK_KEYBOARD_NAME
    default "Etha Pad M"
endif
```
